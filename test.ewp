# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: \\wsl.localhost\Ubuntu-20.04\home\stone\code\test\cpp_learn; \\wsl.localhost\Ubuntu-20.04\home\stone\code\test\demo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
  group cpp_case
    cpp_learn/: 44_菱形继承与虚继承.cpp cpp_learn.cpp cpp_learn.h cpp_learn_iner.h
  group demo
    demo/: demo.cpp demo_test01.cpp
